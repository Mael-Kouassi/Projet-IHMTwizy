# Keil uVision project test.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\test.sct
  group Source Group 1
    ./: GUI_SingleThread.c main.c
  group AW source
    ./appwizard/ihm_twizy/Source/: APPW_MainTask.c
    ./appwizard/ihm_twizy/Source/CustomCode/: Application.c ID_SCREEN_00_Slots.c
    ./appwizard/ihm_twizy/Source/Generated/: APPWConf.c ID_SCREEN_00.c Resource.c
  group AW resources
    ./appwizard/ihm_twizy/Resource/Image/: flechepetit.c flechepetitdroite.c DARK_Progbar_Tile_V_Gray_16x1.c pharesdecroisementpetit.c feuxderoutepetit.c batterietemppetit.c DARK_Progbar_Tile_H_Green_1x16.c DARK_Switch_Body_H_Off_55x20.c DARK_Switch_Body_H_On_55x20.c DARK_Switch_Thumb_26x26.c fprondpetit.c routepetit.c freinamainoffp.c feuxdecroisementonp.c feuxderouteonp.c DARK_Image_DiagLinesGray_40x40.c RenaultLogop.c
    ./appwizard/ihm_twizy/Resource/Text/: APPW_Language_0.c
    ./appwizard/ihm_twizy/Resource/Font/: NettoOT_24_Normal_EXT_AA4.c NettoOT_32_Normal_EXT_AA4.c
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:Touchscreen 1.1.1, Board Support:emWin LCD 1.1.1, CMSIS Driver:CAN 1.6.0, Device:STM32Cube Framework:Classic 1.2.0, Device:STM32Cube HAL:Common 1.2.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:DMA 1.2.0, Device:STM32Cube HAL:DMA2D 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:I2C 1.2.0, Device:STM32Cube HAL:LTDC 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:RCC 1.2.0, Device:STM32Cube HAL:SDRAM 1.2.0, Device:STM32Cube HAL:UART 1.2.0, Device:Startup 1.2.0, Graphics Display:STM32F746G-Discovery 1.0.0, Graphics:CORE 6.32.3, Graphics:Input Device:Touchscreen 6.32.3
